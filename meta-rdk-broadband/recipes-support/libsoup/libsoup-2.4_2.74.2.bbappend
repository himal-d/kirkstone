FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append += " file://0001-RDKB-42894-UPnP-Refactor-is-configuring-as-false-whi.patch"
