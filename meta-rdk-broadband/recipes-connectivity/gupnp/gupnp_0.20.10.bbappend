FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append += " file://0001-RDKB-42894-UPnP-Refactor-is-configuring-as-false-whi.patch"
