# Dummy function just to satisfy any component that inherits this class.
# This is only for build purposes.
