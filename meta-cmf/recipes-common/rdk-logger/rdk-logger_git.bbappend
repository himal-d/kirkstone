DEPENDS_append_camera = " iarmbus"
