DEPENDS_camera += "breakpad"
DEPENDS_extender += "breakpad"
