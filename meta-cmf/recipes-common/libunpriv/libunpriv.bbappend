inherit coverity
PV = "${RDK_RELEASE}+git${SRCPV}"
