SRC_URI_remove = "git://github.com/KDE/heaptrack"
SRC_URI += "git://github.com/KDE/heaptrack;protocol=https;branch=master"
