SRC_URI_remove = "${SOURCEFORGE_MIRROR}/jsoncpp/jsoncpp-src-${PV}.tar.gz"
SRC_URI += "https://src.fedoraproject.org/repo/pkgs/jsoncpp/jsoncpp-src-0.6.0-rc2.tar.gz/363e2f4cbd3aeb63bf4e571f377400fb/jsoncpp-src-0.6.0-rc2.tar.gz"
