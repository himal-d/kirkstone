EXTRA_OECMAKE+="-DJSONCPP_WITH_PKGCONFIG_SUPPORT=ON"
