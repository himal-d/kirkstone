SRC_URI_remove =  "git://github.com/xianyi/OpenBLAS.git;branch=develop"
SRC_URI +=  "git://github.com/xianyi/OpenBLAS.git;protocol=https;branch=develop"
