require recipes-core/images/rdk-generic.inc
