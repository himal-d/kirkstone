require lxc-image.inc
require recipes-core/images/rdk-generic.inc
