SRC_URI_remove = "file://CVE-2018-1000500.patch"
