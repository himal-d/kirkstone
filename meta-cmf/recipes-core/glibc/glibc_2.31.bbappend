# CVE-2022-23219_fix.patch causes compilation issues
SRC_URI_remove = "file://CVE-2022-23219_fix.patch"

# CVE-2020-27618_fix.patch has already been applied.
SRC_URI_remove = "file://CVE-2020-27618_fix.patch"

# CVE-2020-29562_fix.patch has already been applied.
SRC_URI_remove = "file://CVE-2020-29562_fix.patch"
