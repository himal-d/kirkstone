SRC_URI_remove = "gitsm://github.com/containers/crun;branch=main"
SRC_URI_dunfell += "gitsm://github.com/containers/crun;protocol=https;branch=main"
