SRC_URI_remove = "git://github.com/xmidt-org/cimplog.git"
SRC_URI += "git://github.com/xmidt-org/cimplog.git;protocol=https;branch=master"
