SRC_URI_remove = "git://github.com/xmidt-org/cjwt.git"
SRC_URI += "git://github.com/xmidt-org/cjwt.git;protocol=https;branch=master"

