SRC_URI_remove = "git://github.com/xmidt-org/webcfg.git"
SRC_URI += "git://github.com/xmidt-org/webcfg.git;protocol=https;branch=master"
