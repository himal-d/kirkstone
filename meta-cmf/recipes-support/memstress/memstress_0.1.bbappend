LIC_FILES_CHKSUM_remove = "file://LICENSE;md5=175792518e4ac015ab6696d16c4f607e"
LIC_FILES_CHKSUM = "file://../LICENSE;md5=175792518e4ac015ab6696d16c4f607e"

SRCREV = "${AUTOREV}"

inherit coverity
PV = "${RDK_RELEASE}+git${SRCPV}"
