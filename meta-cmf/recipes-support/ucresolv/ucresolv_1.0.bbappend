SRC_URI_remove = "git://github.com/Comcast/libucresolv.git"
SRC_URI += "git://github.com/Comcast/libucresolv.git;protocol=https;branch=master"
