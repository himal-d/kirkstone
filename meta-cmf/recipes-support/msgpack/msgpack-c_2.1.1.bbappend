DEPENDS_morty = "boost gtest"
