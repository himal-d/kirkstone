SRC_URI_remove = "git://github.com/xmidt-org/wdmp-c.git"
SRC_URI += "git://github.com/xmidt-org/wdmp-c.git;protocol=https;branch=master"
