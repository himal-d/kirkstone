SRC_URI_remove = "git://github.com/Comcast/paroduscl.git"
SRC_URI += "git://github.com/Comcast/paroduscl.git;protocol=https;branch=master"
