SRC_URI_remove = "git://github.com/Comcast/libparodus.git"
SRC_URI += "git://github.com/Comcast/libparodus.git;protocol=https;branch=master"
