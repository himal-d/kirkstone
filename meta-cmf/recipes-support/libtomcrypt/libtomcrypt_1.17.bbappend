SRC_URI_remove = "git://github.com/libtom/libtomcrypt.git;branch=develop"
SRC_URI += "git://github.com/libtom/libtomcrypt.git;branch=develop;protocol=https"
SRCREV = "e6be20bfc7e92c91dc1ef9cb5cc11a326e41f706"
PV = ""
