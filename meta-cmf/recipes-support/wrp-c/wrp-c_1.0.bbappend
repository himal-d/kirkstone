SRC_URI_remove = "git://github.com/xmidt-org/wrp-c.git"
SRC_URI += "git://github.com/xmidt-org/wrp-c.git;protocol=https;branch=master"
