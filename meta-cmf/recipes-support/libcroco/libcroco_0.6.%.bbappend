SRC_URI_remove = " file://CVE-2020-12825_fix.patch"
