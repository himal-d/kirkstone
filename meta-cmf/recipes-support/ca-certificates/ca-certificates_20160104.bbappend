FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Remove-expiring-CA-DST-Root-CA-X3-cert-morty.patch"
