BASE_SRC_URI_remove = "http://download.icu-project.org/files/icu4c/64.1/icu4c-64_1-src.tgz"
BASE_SRC_URI += "https://github.com/unicode-org/icu/releases/download/release-64-1/icu4c-64_1-src.tgz"
