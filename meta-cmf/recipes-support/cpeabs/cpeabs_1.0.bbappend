SRC_URI_remove = "git://github.com/xmidt-org/cpeabs.git"
SRC_URI += "git://github.com/xmidt-org/cpeabs.git;protocol=https;branch=master"
