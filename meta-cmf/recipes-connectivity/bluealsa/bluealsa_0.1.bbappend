
# Fix SRCREV to "Fix premature IO threads startup for oFono service",  Feb 19 2022
# Latest commits added dependency on spandsp
SRCREV  = "6509c47c27219a08a64373239469e6f7a5549303"

DEPENDS += " libbsd"
