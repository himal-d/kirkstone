SRC_URI += "file://openssl_no_md4.patch"
