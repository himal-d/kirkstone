SRC_URI_remove = "${SOURCEFORGE_MIRROR}/${BPN}/${BPN}-${PV}.tar.gz"
SRC_URI += "https://datapacket.dl.sourceforge.net/project/libmtp/libmtp/1.1.5/libmtp-1.1.5.tar.gz"
