LICENSE_kirkstone = "GPLv2 & (LGPLv2.1 | MPL-1.1 | BSD-3-Clause)"

