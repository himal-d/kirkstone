SRC_URI_remove = "http://www.openssl.org/source/openssl-${PV}.tar.gz"
SRC_URI += "https://www.openssl.org/source/old/1.1.0/openssl-${PV}.tar.gz"

SRC_URI_remove = "file://0001-TCXB6-9394-Modify-default-cipher-list-to-include-3DE.patch"
