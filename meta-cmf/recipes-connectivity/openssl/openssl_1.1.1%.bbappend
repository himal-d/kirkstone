EXTRA_OECONF_remove_broadband = "no-md4"
EXTRA_OECONF_remove_extender = "no-md4"

EXTRA_OECONF_remove_camera = "no-rc4"
