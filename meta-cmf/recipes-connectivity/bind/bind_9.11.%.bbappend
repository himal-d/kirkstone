# These patches have already been applied in bind-9.11.22
SRC_URI_remove = "file://CVE-2020-8619_fix.patch"
SRC_URI_remove = "file://CVE-2020-8622_fix.patch"
SRC_URI_remove = "file://CVE-2020-8623_fix.patch"
SRC_URI_remove = "file://CVE-2020-8624_fix.patch"
SRC_URI_remove = "file://CVE-2020-8625_fix.patch "

