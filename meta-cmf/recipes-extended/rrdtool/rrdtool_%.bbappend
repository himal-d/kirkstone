PACKAGECONFIG_append = " graph"
