SRC_URI_remove = "git://github.com/rdkcentral/rdkservices.git;protocol=git;branch=main"
SRC_URI += "git://github.com/rdkcentral/rdkservices.git;protocol=https;branch=main"

inherit coverity
