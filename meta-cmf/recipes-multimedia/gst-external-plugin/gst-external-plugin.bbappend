LIC_FILES_CHKSUM = "file://../../COPYING;md5=db791dc95f6a08e8e4d206839bc67ec0"
INSANE_SKIP_${PN} += "dev-so staticdev"
inherit coverity
