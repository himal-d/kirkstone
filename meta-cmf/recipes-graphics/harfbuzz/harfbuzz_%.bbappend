EXTRA_OECONF_remove = "--with-cairo=no"
EXTRA_OECONF += "--with-cairo=no"
