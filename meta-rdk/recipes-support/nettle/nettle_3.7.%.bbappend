EXTRA_OECONF_append = " --enable-mini-gmp"
