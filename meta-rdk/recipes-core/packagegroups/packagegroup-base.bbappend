RDEPENDS_packagegroup-base-zeroconf = "\
    "

