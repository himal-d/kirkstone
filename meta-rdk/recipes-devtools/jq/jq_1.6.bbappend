# Build jq statically
EXTRA_OECONF_append_class-native = " --enable-all-static "
