FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://openssl_no_md4_2.10.patch"
