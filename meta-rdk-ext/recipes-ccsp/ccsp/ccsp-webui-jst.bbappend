FILESEXTRAPATHS_prepend := "${THISDIR}/ccsp-webui-jst:"

SRC_URI_append_broadband = " file://CVE-2020-11022_fix.patch "
