FILESEXTRAPATHS_prepend := "${THISDIR}/ccsp-webui-bci:"

SRC_URI_append_broadband = " file://CVE-2020-11022_fix.patch \
                           "

