FILESEXTRAPATHS_prepend:="${THISDIR}/${PN}:"

SRC_URI_append_broadband  = " file://CVE-2020-26154_libproxy_0.4.13_fix.patch  "
