FILESEXTRAPATHS_prepend:="${THISDIR}/files:"

SRC_URI_append = " file://CVE-2019-3821_fix.patch "
