FILESEXTRAPATHS_prepend:="${THISDIR}/${PN}:"

SRC_URI_append_video = " file://CVE-2022-1586_fix.patch "
