FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI_append_class-target = "file://CVE-2016-7543.patch \
                               file://CVE-2016-9401.patch \
                              "
