FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://CVE-2019-9924.patch \
            file://CVE-2019-18276.patch \
"
