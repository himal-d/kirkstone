FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append  =  " file://CVE-2021-3200_fix.patch "
