SRC_URI_append = " \
           file://fix_pollfd_dispatch.patch \
           "
