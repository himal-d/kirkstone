SRC_URI_append = " \
           file://log_conntion_failures.patch \
           file://happy_eyeballs_v0.patch \
           file://fix_pollfd_dispatch.patch \
           "
