RDEPENDS:${PN}-conch_remove_kirkstone = "${PYTHON_PN}-cryptography"
