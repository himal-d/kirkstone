DEPENDS_append = " libbsd"
LDFLAGS_append = " -lbsd"
