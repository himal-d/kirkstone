DEPENDS += "breakpad-wrapper"

inherit coverity
