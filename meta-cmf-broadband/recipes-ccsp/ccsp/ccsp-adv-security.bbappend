SRC_URI_remove = "${RDKB_CCSP_ROOT_GIT}/CcspAdvSecurity/generic;protocol=${RDK_GIT_PROTOCOL};branch=${CCSP_GIT_BRANCH};name=ccsp-adv-security"
SRC_URI += "${CMF_GIT_ROOT}/rdkb/components/opensource/ccsp/CcspAdvSecurity;protocol=${CMF_GIT_PROTOCOL};branch=${CMF_GIT_BRANCH};name=ccsp-adv-security"
