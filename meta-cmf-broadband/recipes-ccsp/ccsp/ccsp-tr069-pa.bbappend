PV_kirkstone = "${RDK_RELEASE}+git${SRCPV}"
