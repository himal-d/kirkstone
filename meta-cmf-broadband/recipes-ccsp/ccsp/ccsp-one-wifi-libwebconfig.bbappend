inherit coverity
