inherit coverity

DEPENDS_remove = "cpgc"
DEPENDS_remove = "lxy"
