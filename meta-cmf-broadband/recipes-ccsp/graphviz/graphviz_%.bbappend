PACKAGECONFIG_remove_kirkstone  = "librsvg"
