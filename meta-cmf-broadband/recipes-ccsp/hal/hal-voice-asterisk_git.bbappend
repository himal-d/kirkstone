inherit coverity

RDEPENDS_${PN}_remove = "asterisk"
