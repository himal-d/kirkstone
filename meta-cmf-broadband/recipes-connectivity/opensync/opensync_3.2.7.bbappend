OPENSYNC_CORE_REPO_PROTOCOL = "https"
OPENSYNC_PLATFORM_REPO_PROTOCOL = "https"
OPENSYNC_VENDOR_REPO_PROTOCOL = "https"
