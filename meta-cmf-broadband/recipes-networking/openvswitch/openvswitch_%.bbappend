SRC_URI_remove = "file://CVE-2021-3905_fix.patch"
SRC_URI_remove_kirkstone = "file://CVE-2021-36980_fix.patch"
