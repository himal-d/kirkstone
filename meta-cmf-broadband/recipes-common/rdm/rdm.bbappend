DEPENDS_remove = "mountutils"

EXTRA_OECONF_remove = "--enable-mountutils"
