FILES_${PN} += "${base_libdir}/rdk/"

